Commit message: state represented by 3 frame

File: examples/pybullet/gym/pybullet_data/cube_rotate.urdf (robot description, URDF)
Before this commit: robot cube, 2 links, 1 joints
Links:
- link baseLink: geometry collision box size=1 1 1; visual mesh filename=cube.obj scale=0.05 0.05 0.05
